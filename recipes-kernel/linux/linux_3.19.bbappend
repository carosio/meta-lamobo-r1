SRCREV_pn-${PN} = "c0546fe54ef28e3bc98b061642e13ade5d8dabb2"

SRC_URI = "git://github.com/pokymobo/linux-yocto-lamobo-r1.git;protocol=git \
        file://defconfig \
        "
