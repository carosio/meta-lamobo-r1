require swconfig.inc

do_compile (){
        oe_runmake
}
